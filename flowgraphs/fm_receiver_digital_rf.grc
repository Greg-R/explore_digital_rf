<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_cutoff</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>101.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>150e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'/mnt/ds216/gitrepos/explore_digital_rf/digital_rf_data'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_path</value></param>
<param><key>value</key><value>'/home/raven/digital_rf_data/fm_receiver'</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>101.5e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>97.9e6</value></param>
<param><key>step</key><value>200.0e3</value></param>
<param><key>stop</key><value>104.9e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_width</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>working_samp_rate</value></param>
<param><key>value</key><value>400e3</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>2</value></param>
<param><key>quad_rate</key><value>working_samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/raven/file_sink_data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume * 0.1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>./ch5/fm_audio.wav</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq-center_freq</value></param>
<param><key>decim</key><value>int(samp_rate/working_samp_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,channel_width/2,transition_width)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_channel_sink</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_channel_sink_0</value></param>
<param><key>metadata</key><value>{}</value></param>
<param><key>center_freqs</key><value>101.1e6</value></param>
<param><key>is_continuous</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>dir</key><value>data_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_cadence_ms</key><value>1000</value></param>
<param><key>checksum</key><value>False</value></param>
<param><key>compression_level</key><value>0</value></param>
<param><key>ignore_tags</key><value>False</value></param>
<param><key>input</key><value>fc32</value></param>
<param><key>marching_periods</key><value>True</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>sample_rate_denominator</key><value>1</value></param>
<param><key>sample_rate_numerator</key><value>int(samp_rate)</value></param>
<param><key>start</key><value>time_stamp_start.iso_time</value></param>
<param><key>stop_on_skipped</key><value>False</value></param>
<param><key>subdir_cadence_s</key><value>3600</value></param>
<param><key>uuid</key><value></value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_channel_source</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_channel_source_0</value></param>
<param><key>dir</key><value>data_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>end</key><value></value></param>
<param><key>gapless</key><value>False</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>hide_msg_port</key><value>True</value></param>
<param><key>start</key><value></value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>audio_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>working_samp_rate/2</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>working_samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(working_samp_rate/2)</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>sdrplay_rsp2_source</key>
<param><key>id</key><value>sdrplay_rsp2_source_0</value></param>
<param><key>agc_enabled</key><value>True</value></param>
<param><key>antenna</key><value>'A'</value></param>
<param><key>bw</key><value>5000</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>40</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>0</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>center_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>time_stamp_start</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph

import datetime

iso_time = datetime.datetime.now().replace(microsecond=0).isoformat() +'Z'
</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_channel_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_channel_source_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_channel_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_channel_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp2_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp2_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp2_source_0</source_block_id><sink_block_id>gr_digital_rf_digital_rf_channel_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp2_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
